# Keil uVision project 430BOOST-SENSE1_CapTouch_MSP432P401R.uvprojx, settings and files
target 430BOOST-SENSE1_CapTouch_MSP432P401R (ARM-ADS)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.2.0.0
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 430BOOST-SENSE1_CapTouch_MSP432P401R
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__ TARGET_IS_MSP432P4XX keil
  c include: ..\;..\CTSLibrary;..\driverlib\MSP432P4xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group source
    ../: CapTouchBoosterPack_UserExperience.c structure.c uart.c
  group driverlib
    C:/Users/a0224638/Desktop/Capacitive_Touch_Software_Library_MSP432/Firmware/Source/430BOOST-SENSE1_CapTouch_MSP432P401R/driverlib/MSP432P4xx/keil/: msp432p4xx_driverlib.lib
  group CTSLibrary
    ../CTSLibrary/: CTS_HAL.c CTS_Layer.c
software components: CMSIS:CORE 4.1.0, Device:Startup 2.0.0
